## lab7/lab7_3/sdkconfig.defaults
```kconfig
CONFIG_EXAMPLE_WIFI_SSID="Shreyas iPhone"
CONFIG_EXAMPLE_WIFI_PASSWORD="dantemustdie"
```
